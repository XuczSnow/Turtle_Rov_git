# Keil uVision project Control_STM32.uvprojx, settings and files
target Control_STM32 (6160000::V6.16::ARMCLANG)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Control_STM32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;   ../Drivers/STM32F1xx_HAL_Driver/Inc;   ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;   ../Drivers/CMSIS/Include;   ..\Rov_Turtle\Common;   ..\Rov_Turtle\Common\ex_lib;   ..\Rov_Turtle\Core;   ..\Rov_Turtle\Function;   ..\Rov_Turtle\Thirty_Part;   ..\Rov_Turtle\Letter_Shell\src;   ..\Rov_Turtle\Letter_Shell\usr;   ..\Rov_Turtle\Letter_Shell\extensions\log;   ..\Rov_Turtle\Letter_Shell\extensions\shell_enhance
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
    ./Control_STM32/: Control_STM32.map Control_STM32.htm Control_STM32.hex
  group Application/User/Core
    ../Core/Inc/: main.h
    ../Core/Src/: main.c gpio.c adc.c dma.c iwdg.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Rov_Turtle/Common
    ../Rov_Turtle/Common/: turtle_g.h turtle_bsp.c turtle_bsp.h turtle_it.c turtle_it.h
    ../Rov_Turtle/Common/ex_lib/: crc16_lib.c crc16_lib.h sht_iic_hal.c sht_iic_hal.h sht_system.c sht_system.h sht_typedefs.h onchip_flash.c onchip_flash.h
  group Rov_Turtle/Core
    ../Rov_Turtle/Core/: turtle_autoctrl.c turtle_autoctrl.h turtle_dbg.c turtle_dbg.h turtle_timit.c turtle_timit.h turtle_movectrl.c turtle_movectrl.h turtle_fifo.c turtle_fifo.h turtle_parameters.c turtle_parameters.h
  group Rov_Turtle/Function
    ../Rov_Turtle/Function/: turtle_cam_hk.c turtle_cam_hk.h turtle_gyro_jy901b.c turtle_gyro_jy901b.h turtle_led_j101.c turtle_led_j101.h turtle_lsjc_gpio.c turtle_lsjc_gpio.h turtle_press_x101.c turtle_press_x101.h turtle_prop_485&pwm.c turtle_prop_485&pwm.h turtle_sht_30dis.c turtle_sht_30dis.h turtle_temp_nta8a01_ttl.c turtle_temp_nta8a01_ttl.h turtle_yt_j101.c turtle_yt_j101.h turtle_host.c turtle_host.h turtle_comp_hcm365b.c turtle_comp_hcm365b.h
  group Rov_Turtle/ThirtyPart
    ../Rov_Turtle/Thirty_Part/: de.c de.h
  group Rov_Turtle/Shell/Usr
    ../Rov_Turtle/Letter_Shell/usr/: shell_port.c shell_port.h turtle_cmd.c turtle_cmd.h
  group Rov_Turtle/Shell/Core
    ../Rov_Turtle/Letter_Shell/src/: shell_cfg.h shell.c shell.h shell_cmd_list.c shell_companion.c shell_ext.c shell_ext.h
    ../Rov_Turtle/Letter_Shell/: README.md
  group Rov_Turtle/Shell/Log
    ../Rov_Turtle/Letter_Shell/extensions/log/: log.c log.h readme.md
  group Rov_Turtle/Shell/Enhance
    ../Rov_Turtle/Letter_Shell/extensions/shell_enhance/: shell_cmd_group.c shell_cmd_group.h shell_passthrough.c shell_passthrough.h readme.md
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0
